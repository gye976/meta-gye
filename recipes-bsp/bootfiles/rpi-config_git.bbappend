ENABLE_UART = "1"
ENABLE_SPI_BUS = "1"

ENABLE_I2C = "1"
KERNEL_MODULE_AUTOLOAD:rpi += "i2c-dev i2c-bcm2708"

