PACKAGECONFIG:append = " examples"
PACKAGECONFIG:append = " kms"
PACKAGECONFIG:append = " gbm gles2 eglfs"
PACKAGECONFIG:remove = "gl"

